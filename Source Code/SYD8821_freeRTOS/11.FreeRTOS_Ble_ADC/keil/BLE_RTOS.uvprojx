# Keil uVision project BLE_RTOS.uvprojx, settings and files
target SYD8821_FreeRTOS_Cache (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: SYD8821_FreeRTOS +hex
  AfterMake: "output\HEX2BIN.EXE" "output\SYD8821_FreeRTOS.hex"
  c flags: Optim=1
  c include: ..\..\..\Lib;..\..\..\BLE;..\..\..\Source_FreeRTOS\source\include;..\..\..\Source_FreeRTOS\config;..\..\..\Source_FreeRTOS\portable\ARM\SYD8821;..\..\..\Source_FreeRTOS\portable\CMSIS\SYD8821;..\..\..\Include;..\application;..\profile;..\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3e000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Application
    ../: main.c
  group BLE
    ../application/: ble.c
    ../../../BLE/: ota.c
  group Driver
    ../../../Source/: debug.c pad_mux_ctrl.c gpio.c delay.c gpadc.c clk.c
  group FreeRTOS
    ../../../Source_FreeRTOS/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Source_FreeRTOS/source/portable/MemMang/: heap_4.c
    ../../../Source_FreeRTOS/portable/ARM/SYD8821/: port.c
  group Libraries
    ../../../Lib/: syd8821_ble_slave.lib syd8821_ancs_lib.lib
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
