# Keil uVision project Module_samples.uvprojx, settings and files
target SYD8821 (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: Module_samples +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\Module_samples.hex"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x20020000 size 0x8000
  group Main
    ../: main.c
  group User
    ../User/: pdm_module.c pdm_module.h
  group Algorithm
    ../Algorithm/: adpcm.c adpcm.h
  group Driver
    ../../../Source/: gpio.c delay.c pad_mux_ctrl.c uart.c queue.c pdm.c
    ../User/: debug.c
  group Library
    ../../../Lib/: syd8821_ble_slave.lib
target SYD8821_CACHE (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: Module_samples +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\Module_samples.hex"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Include;..\Algorithm;..\..\..\Lib;..\..\amic;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3e000
  memory RVCT9: RAM 0x20000000 size 0x28000
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
