# Keil uVision project Module_samples.uvprojx, settings and files
target SYD8821 (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: Module_samples +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\Module_samples.hex"
  AfterMake: fromelf -c  .\output\Module_samples.axf  -o  .\output\Module_samples.txt
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Main
    ../: main.c oled_9632.c
  group Driver
    ../../../Source/: gpio.c delay.c pad_mux_ctrl.c uart.c debug.c queue.c i2c_master.c
  group Library
    ../: Syd8821_bootlader_lib.lib
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
