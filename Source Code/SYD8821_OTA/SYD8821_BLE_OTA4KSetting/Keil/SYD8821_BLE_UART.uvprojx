# Keil uVision project SYD8821_BLE_UART.uvprojx, settings and files
target SYD8821 (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: SYD8821_BLE_OTA_Double +hex
  AfterMake: "Output\HEX2BIN.EXE" "Output\SYD8821_BLE_OTA_Double.hex"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Include;..\..\..\BLE;..\..\..\Rtt;..\..\SYD8821_BLE_OTA_Double;..\..\..\Lib;..\profile
  memory RVCT4: ROM 0x10000000 size 0x3e000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Main
    ../: main.c
  group Driver
    ../../../Source/: gpio.c delay.c pad_mux_ctrl.c uart.c debug.c queue.c timer.c
  group Library
    ../../../Lib/: syd8821_ble_slave.lib
  group Ble
    ../../../BLE/: otaV30.c
  group RTT
    ../../../Rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
