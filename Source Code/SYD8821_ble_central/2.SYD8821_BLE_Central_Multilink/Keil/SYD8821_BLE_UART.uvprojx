# Keil uVision project SYD8821_BLE_UART.uvprojx, settings and files
target SYD8821_Master_1V1 (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: SYD8821_Ble_Central +hex
  c flags: OneElfS=1 uC99=1
  c include: ..\..\..\Include;..\..\..\BLE;..\..\..\Rtt;..\;..\..\..\Lib;..\profile
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3e000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Main
    ../: main.c
  group Driver
    ../../../Source/: gpio.c delay.c pad_mux_ctrl.c timer.c
    ../: debug.c
  group Library
    ../../../Lib/: syd8821_ble_master_1V1_20191129.lib syd8821_ble_master_1V2_20191129.lib syd8821_ble_master_1V3_20191129.lib
  group RTT
    ../../../Rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
target SYD8821_Master_1V2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: SYD8821_Ble_Central +hex
  c flags: OneElfS=1 uC99=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3e000
  memory RVCT9: RAM 0x20000000 size 0x28000
target SYD8821_Master_1V3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: SYD8821_Ble_Central +hex
  c flags: OneElfS=1 uC99=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3e000
  memory RVCT9: RAM 0x20000000 size 0x28000
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
